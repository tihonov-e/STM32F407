# Keil uVision project Lab1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\Config;D:\Keil_v5\lib\STM32F4xx\STM32F4xx_StdPeriph_Driver\inc;D:\Keil_v5\lib\STM32F4xx\STM32F4xx_StdPeriph_Driver\src;.\Config;D:\Keil_v5\lib\STM32F4xx\CMSIS\Device\ST\STM32F4xx\Include;D:\Keil_v5\lib\STM32F4xx\CMSIS\Include;D:\Keil_v5\lib\STM32F4xx\CMSIS\Device\ST\STM32F4xx;D:\Keil_v5\lib\STM32F4xx\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
  group CMSIS
    D:/Keil_v5/lib/STM32F4xx/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StartUp
    D:/Keil_v5/lib/STM32F4xx/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group StdPeriph
    D:/Keil_v5/lib/STM32F4xx/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
